# Keil uVision project cecnn.uvprojx, settings and files
target cecnn (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: cecnn +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../X-CUBE-AI/App;../X-CUBE-AI;../X-CUBE-AI/Target;../Middlewares/ST/AI/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../HARDWARE/DHT11;../HARDWARE/KEY;../HARDWARE/LCD;../SYSTEM/delay;../SYSTEM/sys;../SYSTEM/usart
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: cecnn.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/X-CUBE-AI/App
    ../X-CUBE-AI/App/: cecnn.c cecnn_data.c cecnn_data_params.c aiPbIO.c aiPbMemRWServices.c aiPbMgr.c aiValidation.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c aiTestHelper.c aiTestUtility.c ai_device_adaptor.c lc_print.c app_x-cube-ai.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c fsmc.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../X-CUBE-AI/App/: syscalls.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime810_CM4_Keil.lib
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
software components: CMSIS:CORE 4.3.0
